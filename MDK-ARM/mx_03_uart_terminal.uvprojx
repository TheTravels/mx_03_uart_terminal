# Keil uVision project mx_03_uart_terminal.uvprojx, settings and files
target mx_03_uart_terminal (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: mx_03_uart_terminal
  c flags: Optim=4 OneElfS=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F030x8
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F0xx_HAL_Driver/Inc;  ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;  ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart.c stm32f0xx_hal_pwr.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c
  group New Group
    ../Boot/: flash.c bl.c
    ../uart/: terminal_8266.c terminal.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c croutine.c queue.c tasks.c event_groups.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User
    ../Src/: freertos.c stm32f0xx_it.c dma.c gpio.c main.c stm32f0xx_hal_msp.c usart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
software components: CMSIS:CORE 4.1.0
